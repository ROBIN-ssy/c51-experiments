#include <STC89C5xRC.H>
#include "Delay.h"
#include "MatrixLED.h"

unsigned char code Animation[]={
		0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
		0x30,0x48,0x44,0x22,0x44,0x48,0x30,0x00,//♥
		0xFE,0x02,0x02,0x02,0x02,0x00,0xFE,0x82,
		0x82,0x82,0xFE,0x00,0x00,0x00,0xE0,0x18,
		0x04,0x02,0x04,0x18,0xE0,0x00,0x00,0x00,
		0xFE,0x92,0x92,0x92,0x92,0x00,0x00,0xFA,0x00,0x00,
		0x30,0x48,0x44,0x22,0x44,0x48,0x30,0x00,//♥
		0x00,0x00,0x00,0x00,0x00,0x00,0x00,0x00,
};

void main()
{
		unsigned char i,Offest=0,Count=0;
		MatrixLED_Init();
		while(1)
		{
				for(i=0;i<8;i++)
				{
						MatrixLED_ShowColumn(i,Animation[i+Offest]);
				}
				Count++;
				if(Count>10)
				{
						Count=0;
						Offest++;
					if(Offest>58)
					{
							Offest=0;
					}
				}
		}

}